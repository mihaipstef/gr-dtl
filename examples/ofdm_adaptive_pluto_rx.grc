options:
  parameters:
    generate_options: qt_gui
    id: ofdm_adaptive_pluto_rx
    output_language: python
    title: OFDM Adaptive RX
  states: {}

blocks:
- name: json_config
  id: json_config
  parameters:
    config_file: /home/ubuntu-lab/dtl-flows/gr-dtl/examples/ofdm_adaptive_pluto.run.json
  states: {}
- name: resampling
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: json_config["sample_rate"]
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: json_config["feedback_anticlipping"]
    type: complex
  states: {}
- name: dtl_ofdm_adaptive_rx_0
  id: dtl_ofdm_adaptive_rx
  parameters:
    cp_len: '16'
    fft_len: '64'
    occupied_carriers: ''
    pilot_carriers: ''
    pilot_symbols: ''
    rolloff: '0'
    scramble_bits: 'False'
    use_sync_correct: 'False'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: samp_rate
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: json_config["feedback_carrier"]
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.3.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: samp_rate
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: json_config["direct_carrier"]
    gain1: '''slow_attack'''
    manual_gain1: '70'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.3.1
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 192.168.0.102
    header: '0'
    payloadsize: '1316'
    port: '9001'
    send_eof: 'False'
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 1,1,1,1
    name: Equalized constellation
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: int(samp_rate)
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,1
    name: '"RX Spectrum"'
    type: complex
    update_time: '0.1'
    ymax: '-20'
    ymin: '-110'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,1,1,1
    name: Feedback TX spectrum
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 1,0,1,1
    name: Data
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 3,0,1,2
    name: Frequency offset
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: resampling
    fbw: '0.49'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.49'
    interp: resampling
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: sync_detect
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: decided_cnst
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: sync_correct
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://*:5551
    timeout: '100'
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0_0, '0']
- [dtl_ofdm_adaptive_rx_0, '0', blocks_char_to_float_0, '0']
- [dtl_ofdm_adaptive_rx_0, '0', network_udp_sink_0, '0']
- [dtl_ofdm_adaptive_rx_0, '1', blocks_multiply_const_vxx_0, '0']
- [dtl_ofdm_adaptive_rx_0, '2', virtual_sink_0, '0']
- [dtl_ofdm_adaptive_rx_0, '3', virtual_sink_0_1, '0']
- [dtl_ofdm_adaptive_rx_0, '4', virtual_sink_0_0, '0']
- [dtl_ofdm_adaptive_rx_0, '5', qtgui_const_sink_x_0, '0']
- [dtl_ofdm_adaptive_rx_0, '6', qtgui_time_sink_x_0_0, '0']
- [dtl_ofdm_adaptive_rx_0, monitor, zeromq_pub_msg_sink_0, in]
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', dtl_ofdm_adaptive_rx_0, '0']
- [rational_resampler_xxx_0_0, '0', iio_pluto_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
