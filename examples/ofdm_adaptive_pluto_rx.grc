options:
  parameters:
    generate_options: qt_gui
    id: ofdm_adaptive_pluto_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amp
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: resampling
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '-40000'
    step: '10'
    stop: '40000'
    value: '35850'
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '2.0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: variable_qtgui_range_0
    offset: '0'
    phase: '0'
    samp_rate: '600000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/sync-detect.dat
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/sync-correct.dat
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: dtl_ofdm_adaptive_rx_0
  id: dtl_ofdm_adaptive_rx
  parameters:
    cp_len: '16'
    debug: 'False'
    fft_len: '64'
    occupied_carriers: ''
    pilot_carriers: ''
    pilot_symbols: ''
    rolloff: '0'
    scramble_bits: 'False'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '400000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '850000000'
    samplerate: '600000'
    type: fc32
    uri: ip:192.168.3.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '300000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2400000000'
    gain1: '''slow_attack'''
    manual_gain1: '60'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '600000'
    type: fc32
    uri: ip:192.168.3.1
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: '600000'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '600000'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '200000'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '200000'
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: resampling
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: resampling
    type: ccc
  states: {}

connections:
- [analog_agc3_xx_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [dtl_ofdm_adaptive_rx_0, '0', blocks_char_to_float_0, '0']
- [dtl_ofdm_adaptive_rx_0, '1', blocks_multiply_const_vxx_0, '0']
- [dtl_ofdm_adaptive_rx_0, '1', blocks_null_sink_0, '0']
- [dtl_ofdm_adaptive_rx_0, '2', blocks_file_sink_0, '0']
- [dtl_ofdm_adaptive_rx_0, '2', blocks_null_sink_0_0, '0']
- [dtl_ofdm_adaptive_rx_0, '3', blocks_file_sink_0_0, '0']
- [dtl_ofdm_adaptive_rx_0, '3', blocks_null_sink_0_0_0, '0']
- [dtl_ofdm_adaptive_rx_0, feedback, blocks_message_debug_0, print]
- [iio_pluto_source_0, '0', analog_agc3_xx_0, '0']
- [iio_pluto_source_0, '0', blocks_multiply_xx_0, '1']
- [rational_resampler_xxx_0, '0', dtl_ofdm_adaptive_rx_0, '0']
- [rational_resampler_xxx_0_0, '0', iio_pluto_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
