options:
  parameters:
    generate_options: qt_gui
    id: ofdm_adaptive_pluto_rx
    output_language: python
    title: OFDM Adaptive RX
  states: {}

blocks:
- name: direct_carrier
  id: variable
  parameters:
    value: json_config.get("direct_carrier", 2100000000)
  states: {}
- name: feedback_carrier
  id: variable
  parameters:
    value: json_config.get("feedback_carrier", 850000000)
  states: {}
- name: feedback_tx_amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Anti clipping factor
    start: '0.001'
    step: '0.02'
    stop: '2'
    value: '0.02'
    widget: counter
  states: {}
- name: json_config
  id: json_config
  parameters:
    config_file: /home/tflab/gr-dtl/examples/config_fec.json
  states: {}
- name: pluto_uri
  id: variable
  parameters:
    value: '"ip:192.168.3.1"'
  states: {}
- name: resampling
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: json_config.get("sample_rate", 700000)
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: feedback_tx_amp
    type: complex
  states: {}
- name: dtl_ofdm_adaptive_rx_0
  id: dtl_ofdm_adaptive_rx
  parameters:
    len_tag_key: len_tag_key
    ofdm_config: json_config.get("ofdm_config", {})
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: samp_rate
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: feedback_carrier
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.3.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: samp_rate
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: direct_carrier
    gain1: '''slow_attack'''
    manual_gain1: '70'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.3.1
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 1,1,1,1
    name: Equalized constellation
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: int(samp_rate)
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,1
    name: '"RX Spectrum"'
    type: complex
    update_time: '0.1'
    ymax: '-20'
    ymin: '-110'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,1,1,1
    name: Feedback TX spectrum
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 1,0,1,1
    name: Data
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 3,0,1,2
    name: Frequency offset
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: resampling
    fbw: '0.49'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.49'
    interp: resampling
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: sync_detect
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: decided_cnst
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: sync_correct
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://*:5551
    timeout: '100'
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0_0, '0']
- [dtl_ofdm_adaptive_rx_0, '0', blocks_char_to_float_0, '0']
- [dtl_ofdm_adaptive_rx_0, '1', blocks_multiply_const_vxx_0, '0']
- [dtl_ofdm_adaptive_rx_0, '2', virtual_sink_0, '0']
- [dtl_ofdm_adaptive_rx_0, '3', virtual_sink_0_1, '0']
- [dtl_ofdm_adaptive_rx_0, '4', virtual_sink_0_0, '0']
- [dtl_ofdm_adaptive_rx_0, '5', qtgui_const_sink_x_0, '0']
- [dtl_ofdm_adaptive_rx_0, '6', qtgui_time_sink_x_0_0, '0']
- [dtl_ofdm_adaptive_rx_0, monitor, zeromq_pub_msg_sink_0, in]
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', dtl_ofdm_adaptive_rx_0, '0']
- [rational_resampler_xxx_0_0, '0', iio_pluto_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
