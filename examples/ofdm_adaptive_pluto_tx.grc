options:
  parameters:
    generate_options: qt_gui
    id: ofdm_adaptive_pluto_tx
    output_language: python
    title: OFDM Adaptive TX
  states: {}

blocks:
- name: direct_carrier
  id: variable
  parameters:
    value: json_config.get("direct_carrier", 2100000000)
  states: {}
- name: feedback_carrier
  id: variable
  parameters:
    value: json_config.get("feedback_carrier", 850000000)
  states: {}
- name: json_config
  id: json_config
  parameters:
    config_file: /home/tflab/gr-dtl/examples/config_fec.json
  states: {}
- name: pluto_uri
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {}
- name: resampling
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: json_config.get("sample_rate", 700000)
  states: {}
- name: tx_amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Anti clipping factor
    start: '0.001'
    step: '0.02'
    stop: '2'
    value: '0.02'
    widget: counter
  states: {}
- name: tx_at
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Pluto TX attenuation
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
    widget: counter
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '95'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: '2500'
    type: byte
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_amp
    type: complex
  states: {}
- name: dtl_ofdm_adaptive_tx_0
  id: dtl_ofdm_adaptive_tx
  parameters:
    len_tag_key: len_tag_key
    ofdm_config: json_config.get("ofdm_config", {})
    sample_rate: samp_rate
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_at
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: direct_carrier
    samplerate: samp_rate
    type: fc32
    uri: pluto_uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: samp_rate
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: feedback_carrier
    gain1: '''manual'''
    manual_gain1: '10'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: pluto_uri
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,1,1,1
    name: TX Spectrum
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: int(samp_rate)
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,1
    name: Feedback RX Spectrum
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,2
    name: TX SIgnal
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '0.675'
    ymin: '-0.675'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.49'
    interp: resampling
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: resampling
    fbw: '0.49'
    interp: '1'
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0, '0', dtl_ofdm_adaptive_tx_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [dtl_ofdm_adaptive_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [dtl_ofdm_adaptive_tx_0, monitor, blocks_message_debug_0, store]
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_1, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_1, '0']
- [rational_resampler_xxx_0_0, '0', dtl_ofdm_adaptive_tx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
