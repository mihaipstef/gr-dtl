options:
  parameters:
    generate_options: qt_gui
    id: ofdm_adaptive_pluto_tx
    output_language: python
    title: OFDM Adaptive TX
  states: {}

blocks:
- name: json_config
  id: json_config
  parameters:
    config_file: /home/ubuntu-lab/dtl-flows/gr-dtl/examples/ofdm_adaptive_pluto.run.json
  states: {}
- name: resampling
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: json_config["sample_rate"]
  states: {}
- name: tx_amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Anti clipping factor
    outputmsgname: value
    showports: 'False'
    start: '0.001'
    step: '0.02'
    stop: '2'
    value: json_config["direct_anticlipping"]
    widget: counter
  states: {}
- name: tx_at
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Pluto TX attenuation
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '50'
    value: json_config["direct_att"]
    widget: counter
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '95'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: '25000'
    type: byte
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/udp.dat
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_amp
    type: complex
  states: {}
- name: dtl_ofdm_adaptive_tx_0
  id: dtl_ofdm_adaptive_tx
  parameters:
    cp_len: '16'
    debug: 'False'
    fft_len: '64'
    occupied_carriers: ''
    pilot_carriers: ''
    pilot_symbols: ''
    rolloff: '0'
    scramble_bits: 'False'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_at
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: json_config["direct_carrier"]
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: samp_rate
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: json_config["feedback_carrier"]
    gain1: '''manual'''
    manual_gain1: '10'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '1316'
    port: '9000'
    src_zeros: 'False'
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,1,1,1
    name: TX Spectrum
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: int(samp_rate)
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,1
    name: Feedback RX Spectrum
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,2
    name: TX SIgnal
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '0.675'
    ymin: '-0.675'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.49'
    interp: resampling
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: resampling
    fbw: '0.49'
    interp: '1'
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0, '0', dtl_ofdm_adaptive_tx_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [dtl_ofdm_adaptive_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [dtl_ofdm_adaptive_tx_0, monitor, blocks_message_debug_0, store]
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_1, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_0_0, '0']
- [network_udp_source_0, '0', blocks_file_sink_0, '0']
- [network_udp_source_0, '0', dtl_ofdm_adaptive_tx_0, '0']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_1, '0']
- [rational_resampler_xxx_0_0, '0', dtl_ofdm_adaptive_tx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
