options:
  parameters:
    generate_options: qt_gui
    id: ofdm_adaptive_example
    output_language: python
    title: OFDM Adaptive Example
  states: {}

blocks:
- name: n_bytes
  id: variable
  parameters:
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: ()
    type: byte
    vector: '[0] * 10 * n_bytes'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.01'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: dtl_ofdm_adaptive_rx_0
  id: dtl_ofdm_adaptive_rx
  parameters: {}
  states: {}
- name: dtl_ofdm_adaptive_rx_config_0
  id: dtl_ofdm_adaptive_rx_config
  parameters:
    cp_len: '16'
    debug: 'False'
    fft_len: '64'
    occupied_carriers: ''
    pilot_carriers: ''
    pilot_symbols: ''
    rolloff: '0'
    scramble_bits: 'False'
  states: {}
- name: dtl_ofdm_adaptive_tx_0
  id: dtl_ofdm_adaptive_tx
  parameters: {}
  states: {}
- name: dtl_ofdm_adaptive_tx_config_0
  id: dtl_ofdm_adaptive_tx_config
  parameters:
    cp_len: '16'
    debug: 'False'
    fft_len: '64'
    occupied_carriers: ''
    pilot_carriers: ''
    pilot_symbols: ''
    rolloff: '0'
    scramble_bits: 'False'
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: feedback_tx
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: data_rx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: feedback_tx
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: data_rx
  states: {}

connections:
- [blocks_vector_source_x_0_0, '0', dtl_ofdm_adaptive_tx_0, '0']
- [blocks_vector_source_x_0_0, '0', fec_ber_bf_0, '0']
- [channels_channel_model_0, '0', dtl_ofdm_adaptive_rx_0, '0']
- [channels_channel_model_0_0, '0', dtl_ofdm_adaptive_tx_0, '1']
- [dtl_ofdm_adaptive_rx_0, '0', virtual_sink_2, '0']
- [dtl_ofdm_adaptive_rx_0, '1', virtual_sink_1, '0']
- [dtl_ofdm_adaptive_rx_0, feedback, blocks_message_debug_0, print]
- [dtl_ofdm_adaptive_tx_0, '0', channels_channel_model_0, '0']
- [dtl_ofdm_adaptive_tx_0, feedback_rcvd, blocks_message_debug_1, print]
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [virtual_source_0, '0', channels_channel_model_0_0, '0']
- [virtual_source_1, '0', fec_ber_bf_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
