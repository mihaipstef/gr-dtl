options:
  parameters:
    generate_options: qt_gui
    id: ofdm_adaptive_example
    output_language: python
    title: OFDM Adaptive Example
  states: {}

blocks:
- name: direct_channel_freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Direct channel frequency offset
    outputmsgname: value
    showports: 'False'
    start: '0.001'
    step: '0.001'
    stop: '0.25'
    value: '0.01'
  states: {}
- name: direct_channel_noise_level
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Direct channel noise level
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.0001'
    stop: '3.7'
    value: '0.1'
  states: {}
- name: n_bytes
  id: variable
  parameters:
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '95'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: '10000'
    type: byte
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: direct_channel_freq_offset
    noise_voltage: direct_channel_noise_level
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_selective_fading_model_0
  id: channels_selective_fading_model
  parameters:
    LOS: 'False'
    N: '8'
    delays: (0)
    fDTs: 0/samp_rate
    mags: (1)
    ntaps: '8'
    seed: '0'
  states: {}
- name: dtl_ofdm_adaptive_rx_0
  id: dtl_ofdm_adaptive_rx
  parameters:
    cp_len: '16'
    debug: 'False'
    fft_len: '64'
    occupied_carriers: ''
    pilot_carriers: ''
    pilot_symbols: ''
    rolloff: '0'
    scramble_bits: 'False'
  states: {}
- name: dtl_ofdm_adaptive_tx_0
  id: dtl_ofdm_adaptive_tx
  parameters:
    cp_len: '16'
    debug: 'False'
    fft_len: '64'
    occupied_carriers: ''
    pilot_carriers: ''
    pilot_symbols: ''
    rolloff: '0'
    scramble_bits: 'False'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: qtgui_tab_widget_0@1
    size: '4096'
    type: complex
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3,0,1,2
    label0: Frame trigger
    label1: Equalized payload constellation
    label2: Frequency offset
    num_tabs: '3'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,0,2,1
    size: '2048'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 2,0,1,1
    size: '2048'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: qtgui_tab_widget_0@0
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: qtgui_tab_widget_0@2
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: feedback_tx
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: payload_cnst_eq
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: frequency_offset
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: data_rx
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: payload_cnst_decided
  states: {}
- name: virtual_sink_2_0_0
  id: virtual_sink
  parameters:
    stream_id: frame_trigger
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: feedback_tx
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: payload_cnst_eq
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: frame_trigger
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: frequency_offset
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: data_rx
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://0.0.0.0:5552
    timeout: '100'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_char_to_float_0, '0']
- [analog_sig_source_x_0, '0', dtl_ofdm_adaptive_tx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', channels_selective_fading_model_0, '0']
- [channels_channel_model_0_0, '0', dtl_ofdm_adaptive_tx_0, '1']
- [channels_selective_fading_model_0, '0', dtl_ofdm_adaptive_rx_0, '0']
- [dtl_ofdm_adaptive_rx_0, '0', virtual_sink_2, '0']
- [dtl_ofdm_adaptive_rx_0, '1', virtual_sink_1, '0']
- [dtl_ofdm_adaptive_rx_0, '2', virtual_sink_2_0_0, '0']
- [dtl_ofdm_adaptive_rx_0, '3', virtual_sink_2_0, '0']
- [dtl_ofdm_adaptive_rx_0, '4', virtual_sink_1_0, '0']
- [dtl_ofdm_adaptive_rx_0, '5', virtual_sink_1_0_0, '0']
- [dtl_ofdm_adaptive_rx_0, monitor, zeromq_pub_msg_sink_0, in]
- [dtl_ofdm_adaptive_tx_0, '0', blocks_throttle_0, '0']
- [dtl_ofdm_adaptive_tx_0, monitor, blocks_message_debug_0, store]
- [virtual_source_0, '0', channels_channel_model_0_0, '0']
- [virtual_source_0_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_0_0_0, '0', blocks_char_to_float_0_1, '0']
- [virtual_source_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [virtual_source_1, '0', blocks_char_to_float_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
